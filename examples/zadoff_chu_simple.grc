options:
  parameters:
    generate_options: qt_gui
    id: zadoff_chu_simple
    output_language: python
    title: Zadoff Chu Sync Example
  states: {}

blocks:
- name: ampl
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    label: RX amplitude
    start: '0'
    step: '0.1e-3'
    stop: '10.'
    value: '1.'
  states: {}
- name: chan_taps
  id: variable
  parameters:
    value: '[1. + 1.j, .5 - .0j]'
  states: {}
- name: fq_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: F Offset
    start: '0'
    step: '0.1e-3'
    stop: '3e-3'
    value: '1e-3'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Noise
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e4
  states: {}
- name: scorr_threshold_high
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:6,0,1,1
    label: SCorr Threshold High
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.8'
  states: {}
- name: scorr_threshold_low
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:7,0,1,1
    label: SCorr Threshold Low
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.4'
  states: {}
- name: sync_key
  id: variable
  parameters:
    value: '"fstr"'
  states: {}
- name: sync_seq
  id: variable
  parameters:
    value: ((1+0j), (0.38268343236509+0.92387953251128663j), (0.47139673682599736+0.88192126434835516j), (0.95694033573220838-0.29028467725446411j), (-0.9807852804032311-0.19509032201612519j), (0.83146961230254324-0.55557023301960518j), (0.8819212643483566+0.47139673682599476j), (0.95694033573221149+0.29028467725445356j), (0.38268343236508312-0.92387953251128951j), (-0.70710678118654946+0.70710678118654557j), (-0.098017140329568431-0.99518472667219615j), (0.77301045336273033-0.63439328416365359j), (0.55557023301959785-0.83146961230254812j), (-0.83146961230254079-0.55557023301960895j), (0.63439328416366692+0.77301045336271945j), (-0.99518472667219426+0.098017140329587457j), (-0.70710678118656056-0.70710678118653458j), (-0.92387953251127664-0.38268343236511432j), (-0.29028467725445684+0.9569403357322106j), (0.47139673682599603-0.88192126434835594j), (0.5555702330196175+0.83146961230253502j), (-0.19509032201612977+0.9807852804032301j), (0.2902846772545159+0.95694033573219262j), (0.8819212643483455-0.47139673682601552j), (-0.92387953251128485+0.38268343236509444j), (-1.029755578365977e-14-1j), (0.63439328416366159-0.77301045336272378j), (0.098017140329535263-0.99518472667219937j), (-0.98078528040320134+0.19509032201627444j), (0.98078528040320656-0.19509032201624849j), (-0.098017140329501123+0.9951847266722027j), (-0.63439328416358809+0.77301045336278407j), (5.2443975093426368e-14+1j), (0.92387953251128896-0.38268343236508445j), (-0.88192126434834872+0.47139673682600947j), (-0.29028467725445872-0.95694033573220993j), (0.19509032201618454-0.98078528040321922j), (-0.55557023301976338-0.83146961230243754j), (-0.47139673682593813+0.8819212643483868j), (0.29028467725433582-0.95694033573224724j), (0.92387953251134824+0.3826834323649414j), (0.70710678118665549+0.70710678118643955j), (0.99518472667218627-0.09801714032966842j), (-0.63439328416366692-0.77301045336271945j), (0.83146961230262195+0.55557023301948749j), (-0.55557023301942599+0.83146961230266303j), (-0.77301045336272278+0.6343932841636627j), (0.098017140329584057+0.9951847266721946j), (0.70710678118655568-0.70710678118653936j), (-0.38268343236495633+0.92387953251134203j), (-0.95694033573221948-0.29028467725442725j), (-0.88192126434841156-0.47139673682589189j), (-0.83146961230257888+0.55557023301955188j), (0.98078528040326507+0.19509032201595433j), (-0.95694033573223092+0.29028467725438978j), (-0.47139673682607647-0.88192126434831286j), (-0.38268343236550145-0.92387953251111621j), (-1+8.3336642444405675e-14j), (0.7730104533629697+0.63439328416336194j), (-0.99518472667219016-0.098017140329628383j), (-0.19509032201626822-0.98078528040320256j), (-0.19509032201621632-0.98078528040321289j), (-0.99518472667221924-0.098017140329333827j), (0.77301045336280183+0.63439328416356644j))
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: xcorr_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:5,0,1,1
    label: XCorr Threshold
    start: '0.0'
    step: '1'
    stop: '200.'
    value: '11.'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl * 0.5
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    num_inputs: '2'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    display: 'False'
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: '4096'
    type: complex
    vector: '[0, ] * (4096 - len(2 * sync_seq))'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 2 * sync_seq
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: fq_off
    noise_voltage: noise_voltage
    seed: '0'
    taps: chan_taps / np.sqrt(np.linalg.norm(chan_taps))
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: fq_off
    noise_voltage: noise_voltage
    seed: '0'
    taps: chan_taps / np.sqrt(np.linalg.norm(chan_taps))
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,4,1,1
    label0: Control
    num_tabs: '1'
  states: {}
- name: hier_multicarrier_sync_0
  id: hier_multicarrier_sync
  parameters:
    output_tag_key: sync_key
    ref_preamble: 2 * sync_seq
    sc_high_thr: '.7'
    sc_low_thr: '.6'
    xcorr_comp_freq: 'True'
    xcorr_det_thr: '100.'
  states: {state: disabled}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,2,3
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: '"Synced"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_chan: '1'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: sync_key
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,2,3
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    name: '"SC vs Source"'
    nconnections: '3'
    size: 1024*16
    srate: samp_rate
    tr_chan: '2'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"preamble_start"'
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,3,2,3
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: '"Synced"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_chan: '1'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: sync_key
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: xfdm_sync_sc_delay_corr_0
  id: xfdm_sync_sc_delay_corr
  parameters:
    normalize: 'True'
    seq_len: len(sync_seq)
  states: {}
- name: xfdm_sync_sc_delay_corr_0_0
  id: xfdm_sync_sc_delay_corr
  parameters:
    normalize: 'True'
    seq_len: len(sync_seq)
  states: {}
- name: xfdm_sync_sc_tagger_0
  id: xfdm_sync_sc_tagger
  parameters:
    seq_len: len(sync_seq)
    tag_key: sync_key
    thres_high: scorr_threshold_high
    thres_low: scorr_threshold_low
  states: {}
- name: xfdm_sync_sc_tagger_0_0
  id: xfdm_sync_sc_tagger
  parameters:
    seq_len: len(sync_seq)
    tag_key: sync_key
    thres_high: scorr_threshold_high
    thres_low: scorr_threshold_low
  states: {}
- name: xfdm_sync_sync_tag_align_cc_0
  id: xfdm_sync_sync_tag_align_cc
  parameters:
    num_inputs: '2'
    tag_key: fstr
  states: {}
- name: xfdm_sync_xcorr_tagger_0
  id: xfdm_sync_xcorr_tagger
  parameters:
    sync_sequence: 'sync_seq * 2 '
    tag_key: sync_key
    threshold: xcorr_threshold
    use_sc_rot: 'True'
  states: {}
- name: xfdm_sync_xcorr_tagger_0_0
  id: xfdm_sync_xcorr_tagger
  parameters:
    sync_sequence: 'sync_seq * 2 '
    tag_key: sync_key
    threshold: xcorr_threshold
    use_sc_rot: 'True'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', hier_multicarrier_sync_0, '0']
- [blocks_multiply_const_vxx_0, '0', xfdm_sync_sc_delay_corr_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', xfdm_sync_sc_delay_corr_0_0, '0']
- [blocks_tag_gate_0, '0', xfdm_sync_sync_tag_align_cc_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_vector_insert_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_insert_x_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0, '0']
- [channels_channel_model_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [xfdm_sync_sc_delay_corr_0, '0', xfdm_sync_sc_tagger_0, '0']
- [xfdm_sync_sc_delay_corr_0, '1', xfdm_sync_sc_tagger_0, '1']
- [xfdm_sync_sc_delay_corr_0_0, '0', xfdm_sync_sc_tagger_0_0, '0']
- [xfdm_sync_sc_delay_corr_0_0, '1', xfdm_sync_sc_tagger_0_0, '1']
- [xfdm_sync_sc_tagger_0, '0', blocks_tag_debug_0, '0']
- [xfdm_sync_sc_tagger_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [xfdm_sync_sc_tagger_0, '0', xfdm_sync_xcorr_tagger_0, '0']
- [xfdm_sync_sc_tagger_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [xfdm_sync_sc_tagger_0, '1', xfdm_sync_xcorr_tagger_0, '1']
- [xfdm_sync_sc_tagger_0_0, '0', xfdm_sync_xcorr_tagger_0_0, '0']
- [xfdm_sync_sc_tagger_0_0, '1', xfdm_sync_xcorr_tagger_0_0, '1']
- [xfdm_sync_sync_tag_align_cc_0, '0', blocks_tag_debug_1, '0']
- [xfdm_sync_sync_tag_align_cc_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [xfdm_sync_sync_tag_align_cc_0, '1', blocks_tag_debug_1, '1']
- [xfdm_sync_sync_tag_align_cc_0, '1', qtgui_time_sink_x_0_0_1, '1']
- [xfdm_sync_xcorr_tagger_0, '0', blocks_tag_debug_0, '1']
- [xfdm_sync_xcorr_tagger_0, '0', qtgui_time_sink_x_0_0, '0']
- [xfdm_sync_xcorr_tagger_0, '0', xfdm_sync_sync_tag_align_cc_0, '1']
- [xfdm_sync_xcorr_tagger_0, '1', qtgui_time_sink_x_0_0, '1']
- [xfdm_sync_xcorr_tagger_0_0, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
