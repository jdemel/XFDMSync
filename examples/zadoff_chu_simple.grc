<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>1.</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
<param><key>label</key><value>RX amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1e-3</value></param>
<param><key>stop</key><value>10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_taps</value></param>
<param><key>value</key><value>[1. + 1.j, .5 - .0j]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fq_off</value></param>
<param><key>value</key><value>1e-3</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>F Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1e-3</value></param>
<param><key>stop</key><value>3e-3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_key</value></param>
<param><key>value</key><value>"fstr"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_seq</value></param>
<param><key>value</key><value>((1+0j), (0.38268343236509+0.92387953251128663j), (0.47139673682599736+0.88192126434835516j), (0.95694033573220838-0.29028467725446411j), (-0.9807852804032311-0.19509032201612519j), (0.83146961230254324-0.55557023301960518j), (0.8819212643483566+0.47139673682599476j), (0.95694033573221149+0.29028467725445356j), (0.38268343236508312-0.92387953251128951j), (-0.70710678118654946+0.70710678118654557j), (-0.098017140329568431-0.99518472667219615j), (0.77301045336273033-0.63439328416365359j), (0.55557023301959785-0.83146961230254812j), (-0.83146961230254079-0.55557023301960895j), (0.63439328416366692+0.77301045336271945j), (-0.99518472667219426+0.098017140329587457j), (-0.70710678118656056-0.70710678118653458j), (-0.92387953251127664-0.38268343236511432j), (-0.29028467725445684+0.9569403357322106j), (0.47139673682599603-0.88192126434835594j), (0.5555702330196175+0.83146961230253502j), (-0.19509032201612977+0.9807852804032301j), (0.2902846772545159+0.95694033573219262j), (0.8819212643483455-0.47139673682601552j), (-0.92387953251128485+0.38268343236509444j), (-1.029755578365977e-14-1j), (0.63439328416366159-0.77301045336272378j), (0.098017140329535263-0.99518472667219937j), (-0.98078528040320134+0.19509032201627444j), (0.98078528040320656-0.19509032201624849j), (-0.098017140329501123+0.9951847266722027j), (-0.63439328416358809+0.77301045336278407j), (5.2443975093426368e-14+1j), (0.92387953251128896-0.38268343236508445j), (-0.88192126434834872+0.47139673682600947j), (-0.29028467725445872-0.95694033573220993j), (0.19509032201618454-0.98078528040321922j), (-0.55557023301976338-0.83146961230243754j), (-0.47139673682593813+0.8819212643483868j), (0.29028467725433582-0.95694033573224724j), (0.92387953251134824+0.3826834323649414j), (0.70710678118665549+0.70710678118643955j), (0.99518472667218627-0.09801714032966842j), (-0.63439328416366692-0.77301045336271945j), (0.83146961230262195+0.55557023301948749j), (-0.55557023301942599+0.83146961230266303j), (-0.77301045336272278+0.6343932841636627j), (0.098017140329584057+0.9951847266721946j), (0.70710678118655568-0.70710678118653936j), (-0.38268343236495633+0.92387953251134203j), (-0.95694033573221948-0.29028467725442725j), (-0.88192126434841156-0.47139673682589189j), (-0.83146961230257888+0.55557023301955188j), (0.98078528040326507+0.19509032201595433j), (-0.95694033573223092+0.29028467725438978j), (-0.47139673682607647-0.88192126434831286j), (-0.38268343236550145-0.92387953251111621j), (-1+8.3336642444405675e-14j), (0.7730104533629697+0.63439328416336194j), (-0.99518472667219016-0.098017140329628383j), (-0.19509032201626822-0.98078528040320256j), (-0.19509032201621632-0.98078528040321289j), (-0.99518472667221924-0.098017140329333827j), (0.77301045336280183+0.63439328416356644j))</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>4096</value></param>
<param><key>vector</key><value>[0, ] * (4096 - len(2 * sync_seq))</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>2 * sync_seq</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>fq_off</value></param>
<param><key>noise_voltage</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>chan_taps / np.sqrt(np.linalg.norm(chan_taps))</value></param>
</block>
<block>
<key>hier_multicarrier_sync</key>
<param><key>id</key><value>hier_multicarrier_sync_0</value></param>
<param><key>output_tag_key</key><value>sync_key</value></param>
<param><key>ref_preamble</key><value>2 * sync_seq</value></param>
<param><key>sc_high_thr</key><value>.7</value></param>
<param><key>sc_low_thr</key><value>.6</value></param>
<param><key>xcorr_det_thr</key><value>100.</value></param>
<param><key>xcorr_comp_freq</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>2,0,2,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Synced"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_delay</key><value>200e-6</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>sync_key</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>0,0,2,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>name</key><value>"SC vs Source"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024*8</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>2</value></param>
<param><key>tr_delay</key><value>200e-6</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>"preamble_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>xfdm_sync_sc_delay_corr</key>
<param><key>id</key><value>xfdm_sync_sc_delay_corr_0</value></param>
<param><key>normalize</key><value>True</value></param>
<param><key>seq_len</key><value>len(sync_seq)</value></param>
</block>
<block>
<key>xfdm_sync_sc_tagger</key>
<param><key>id</key><value>xfdm_sync_sc_tagger_0</value></param>
<param><key>thres_low</key><value>0.6</value></param>
<param><key>seq_len</key><value>len(sync_seq)</value></param>
<param><key>tag_key</key><value>sync_key</value></param>
<param><key>thres_high</key><value>0.7</value></param>
</block>
<block>
<key>xfdm_sync_xcorr_tagger</key>
<param><key>id</key><value>xfdm_sync_xcorr_tagger_0</value></param>
<param><key>threshold</key><value>100.</value></param>
<param><key>use_sc_rot</key><value>True</value></param>
<param><key>sync_sequence</key><value>sync_seq * 2 </value></param>
<param><key>tag_key</key><value>sync_key</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>hier_multicarrier_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>xfdm_sync_sc_delay_corr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_vector_insert_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_multicarrier_sync_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xfdm_sync_sc_delay_corr_0</source_block_id><sink_block_id>xfdm_sync_sc_tagger_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>xfdm_sync_sc_delay_corr_0</source_block_id><sink_block_id>xfdm_sync_sc_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xfdm_sync_sc_tagger_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>xfdm_sync_sc_tagger_0</source_block_id><sink_block_id>xfdm_sync_xcorr_tagger_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>xfdm_sync_sc_tagger_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xfdm_sync_sc_tagger_0</source_block_id><sink_block_id>xfdm_sync_xcorr_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xfdm_sync_xcorr_tagger_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>xfdm_sync_xcorr_tagger_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
