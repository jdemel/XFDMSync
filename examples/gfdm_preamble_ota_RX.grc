options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_preamble_ota_RX
    output_language: python
    title: Zadoff Chu OTA Demo
  states: {}

blocks:
- name: chan_taps
  id: variable
  parameters:
    value: '[1. + 1.j, .5 - .0j]'
  states: {}
- name: rgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:4,0,1,1
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '10.'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6 / 64 * 2
  states: {}
- name: scorr_threshold_high
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:6,0,1,1
    label: SCorr Threshold High
    orient: Qt.Horizontal
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.8'
  states: {}
- name: scorr_threshold_low
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:7,0,1,1
    label: SCorr Threshold Low
    orient: Qt.Horizontal
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.4'
  states: {}
- name: sync_key
  id: variable
  parameters:
    value: '"fstr"'
  states: {}
- name: sync_seq
  id: variable
  parameters:
    value: ((1+0j), (0.38268343236509+0.92387953251128663j), (0.47139673682599736+0.88192126434835516j), (0.95694033573220838-0.29028467725446411j), (-0.9807852804032311-0.19509032201612519j), (0.83146961230254324-0.55557023301960518j), (0.8819212643483566+0.47139673682599476j), (0.95694033573221149+0.29028467725445356j), (0.38268343236508312-0.92387953251128951j), (-0.70710678118654946+0.70710678118654557j), (-0.098017140329568431-0.99518472667219615j), (0.77301045336273033-0.63439328416365359j), (0.55557023301959785-0.83146961230254812j), (-0.83146961230254079-0.55557023301960895j), (0.63439328416366692+0.77301045336271945j), (-0.99518472667219426+0.098017140329587457j), (-0.70710678118656056-0.70710678118653458j), (-0.92387953251127664-0.38268343236511432j), (-0.29028467725445684+0.9569403357322106j), (0.47139673682599603-0.88192126434835594j), (0.5555702330196175+0.83146961230253502j), (-0.19509032201612977+0.9807852804032301j), (0.2902846772545159+0.95694033573219262j), (0.8819212643483455-0.47139673682601552j), (-0.92387953251128485+0.38268343236509444j), (-1.029755578365977e-14-1j), (0.63439328416366159-0.77301045336272378j), (0.098017140329535263-0.99518472667219937j), (-0.98078528040320134+0.19509032201627444j), (0.98078528040320656-0.19509032201624849j), (-0.098017140329501123+0.9951847266722027j), (-0.63439328416358809+0.77301045336278407j), (5.2443975093426368e-14+1j), (0.92387953251128896-0.38268343236508445j), (-0.88192126434834872+0.47139673682600947j), (-0.29028467725445872-0.95694033573220993j), (0.19509032201618454-0.98078528040321922j), (-0.55557023301976338-0.83146961230243754j), (-0.47139673682593813+0.8819212643483868j), (0.29028467725433582-0.95694033573224724j), (0.92387953251134824+0.3826834323649414j), (0.70710678118665549+0.70710678118643955j), (0.99518472667218627-0.09801714032966842j), (-0.63439328416366692-0.77301045336271945j), (0.83146961230262195+0.55557023301948749j), (-0.55557023301942599+0.83146961230266303j), (-0.77301045336272278+0.6343932841636627j), (0.098017140329584057+0.9951847266721946j), (0.70710678118655568-0.70710678118653936j), (-0.38268343236495633+0.92387953251134203j), (-0.95694033573221948-0.29028467725442725j), (-0.88192126434841156-0.47139673682589189j), (-0.83146961230257888+0.55557023301955188j), (0.98078528040326507+0.19509032201595433j), (-0.95694033573223092+0.29028467725438978j), (-0.47139673682607647-0.88192126434831286j), (-0.38268343236550145-0.92387953251111621j), (-1+8.3336642444405675e-14j), (0.7730104533629697+0.63439328416336194j), (-0.99518472667219016-0.098017140329628383j), (-0.19509032201626822-0.98078528040320256j), (-0.19509032201621632-0.98078528040321289j), (-0.99518472667221924-0.098017140329333827j), (0.77301045336280183+0.63439328416356644j))
  states: {state: disabled}
- name: tfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:2,0,1,1
    label: Carrier Frequency
    orient: Qt.Horizontal
    start: 2.4e9
    step: '1'
    stop: 3.8e9
    value: 2.484e9
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:3,0,1,1
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '20.'
  states: {}
- name: xcorr_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:5,0,1,1
    label: XCorr Threshold
    orient: Qt.Horizontal
    start: '0.0'
    step: '1'
    stop: '200.'
    value: '11.'
  states: {}
- name: auto_corr_tagger
  id: xfdm_sync_sc_tagger
  parameters:
    seq_len: len(data_reference.core_preamble) // 2
    tag_key: sync_key
    thres_high: scorr_threshold_high
    thres_low: scorr_threshold_low
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: '4096'
    type: complex
    vector: '[0, ] * (4096 - len(data_reference.full_preamble))'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: data_reference.full_preamble
  states: {state: disabled}
- name: corr_mag_sq_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: corr_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: cross_corr_tagger
  id: xfdm_sync_xcorr_tagger
  parameters:
    sync_sequence: data_reference.core_preamble
    tag_key: sync_key
    threshold: xcorr_threshold
    use_sc_rot: 'True'
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,4,1,1
    label0: Control
    num_tabs: '1'
  states: {}
- name: data_reference
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      from gfdm.pygfdm import mapping
      from gfdm.pygfdm import utils
      from gfdm.pygfdm import preamble as pre_module
      from gfdm.pygfdm.gfdm_modulation import modulate_mapped_gfdm_block
      from gfdm.pygfdm.cyclic_prefix import add_cyclic_starfix, get_raised_cosine_ramp, pinch_block, get_window_len


      def generate_payload(timeslots=9, subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          cs_len = ramp_len
          seed = utils.generate_seed('awesome frame')
          d = utils.get_random_qpsk(timeslots * active_subcarriers, seed)
          frame = modulate_mapped_gfdm_block(d, timeslots, subcarriers, active_subcarriers, overlap, .2, dc_free=True)
          symbol = add_cyclic_starfix(frame, cp_len, cs_len)
          window_ramp = get_raised_cosine_ramp(cs_len, get_window_len(cp_len, timeslots, subcarriers, cs_len))
          return pinch_block(symbol, window_ramp)


      def generate_preambles(subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          subcarrier_map = mapping.get_subcarrier_map(subcarriers, active_subcarriers, dc_free=True)
          seed = utils.generate_seed('awesome preamble')
          preambles = pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
          return preambles

      preambles = generate_preambles()
      full_preamble = preambles[0]
      core_preamble = preambles[1]

      print(full_preamble.size)
      print(core_preamble.size)


      payload = generate_payload()

      #reference_frame = np.concatenate((full_preamble, payload))
  states: {}
- name: delay_auto_correlator
  id: xfdm_sync_sc_delay_corr
  parameters:
    normalize: 'False'
    seq_len: len(data_reference.core_preamble) // 2
  states: {}
- name: hier_multicarrier_sync_0
  id: hier_multicarrier_sync
  parameters:
    output_tag_key: sync_key
    ref_preamble: data_reference.core_preamble
    sc_high_thr: '.7'
    sc_low_thr: '.6'
    xcorr_comp_freq: 'True'
    xcorr_det_thr: '100.'
  states: {state: disabled}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: polarwrap_tag_to_stream_value_0
  id: polarwrap_tag_to_stream_value
  parameters:
    dict_key: '"sc_idx"'
    type: int
  states: {}
- name: polarwrap_tag_to_stream_value_0_0
  id: polarwrap_tag_to_stream_value
  parameters:
    dict_key: '"xcorr_idx"'
    type: int
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: int
  states: {state: disabled}
- name: qtgui_time_sink_auto_corr_tagged
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:1,0,1,1
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: '"SC vs Source"'
    nconnections: '2'
    size: 1024*16 * 4
    srate: samp_rate
    tr_chan: '2'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"preamble_start"'
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_receive_stream
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:0,0,1,1
    label1: ''
    label2: ''
    name: '"RX samples"'
    size: 1024*32
    srate: samp_rate
    tr_delay: '200e-6'
    tr_level: '0.02'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"preamble_start"'
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_synchronized_stream
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:2,0,1,1
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: '"Synchronized stream"'
    nconnections: '2'
    size: int(2 ** 14)
    srate: samp_rate
    tr_chan: '1'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: sync_key
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_synchronized_stream_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:3,0,1,1
    label1: ''
    label2: ''
    name: '"auto corr rotation"'
    nconnections: '2'
    size: int(2 ** 10)
    srate: samp_rate
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: sync_key
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,4,3
    label0: Synchronization
    num_tabs: '1'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tfreq
    clock_rate: '0.0'
    dev_addr: '"name=kermit"'
    dev_args: '""'
    gain0: tgain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: tfreq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"name=constantine"'
    dev_args: '""'
    gain0: rgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [auto_corr_tagger, '0', cross_corr_tagger, '0']
- [auto_corr_tagger, '0', qtgui_time_sink_auto_corr_tagged, '0']
- [auto_corr_tagger, '1', corr_mag_squared, '0']
- [auto_corr_tagger, '1', cross_corr_tagger, '1']
- [blocks_int_to_float_0, '0', qtgui_time_sink_synchronized_stream_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_synchronized_stream_0, '1']
- [blocks_vector_insert_x_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_insert_x_0, '0']
- [corr_mag_sq_complex, '0', qtgui_time_sink_auto_corr_tagged, '1']
- [corr_mag_squared, '0', corr_mag_sq_complex, '0']
- [cross_corr_tagger, '0', blocks_null_sink_0, '0']
- [cross_corr_tagger, '0', blocks_tag_debug_0, '0']
- [cross_corr_tagger, '0', polarwrap_tag_to_stream_value_0, '0']
- [cross_corr_tagger, '0', polarwrap_tag_to_stream_value_0_0, '0']
- [cross_corr_tagger, '0', qtgui_time_sink_synchronized_stream, '0']
- [cross_corr_tagger, '1', qtgui_time_sink_synchronized_stream, '1']
- [delay_auto_correlator, '0', auto_corr_tagger, '0']
- [delay_auto_correlator, '1', auto_corr_tagger, '1']
- [polarwrap_tag_to_stream_value_0, '0', blocks_int_to_float_0_0, '0']
- [polarwrap_tag_to_stream_value_0, '0', qtgui_number_sink_0, '0']
- [polarwrap_tag_to_stream_value_0_0, '0', blocks_int_to_float_0, '0']
- [uhd_usrp_source_0, '0', delay_auto_correlator, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_receive_stream, '0']

metadata:
  file_format: 1
