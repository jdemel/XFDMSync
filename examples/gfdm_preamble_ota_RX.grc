options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_preamble_ota_RX
    output_language: python
    title: Zadoff Chu OTA Demo
  states: {}

blocks:
- name: rgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:4,0,1,1
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '10.'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6 / 64 * 2
  states: {}
- name: scorr_threshold_high
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:6,0,1,1
    label: SCorr Threshold High
    orient: Qt.Horizontal
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.8'
  states: {}
- name: scorr_threshold_low
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:7,0,1,1
    label: SCorr Threshold Low
    orient: Qt.Horizontal
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.4'
  states: {}
- name: sync_key
  id: variable
  parameters:
    value: '"fstr"'
  states: {}
- name: tfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:2,0,1,1
    label: Carrier Frequency
    orient: Qt.Horizontal
    start: 2.4e9
    step: '1'
    stop: 3.8e9
    value: 2.484e9
  states: {}
- name: xcorr_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:5,0,1,1
    label: XCorr Threshold
    orient: Qt.Horizontal
    start: '0.0'
    step: '1'
    stop: '200.'
    value: '11.'
  states: {}
- name: auto_corr_tagger
  id: xfdm_sync_sc_tagger
  parameters:
    seq_len: len(data_reference.core_preamble) // 2
    tag_key: sync_key
    thres_high: scorr_threshold_high
    thres_low: scorr_threshold_low
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: corr_mag_sq_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: corr_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: cross_corr_tagger
  id: xfdm_sync_xcorr_tagger
  parameters:
    sync_sequence: data_reference.full_preamble
    tag_key: sync_key
    threshold: xcorr_threshold
    use_sc_rot: 'True'
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,4,1,1
    label0: Control
    num_tabs: '1'
  states: {}
- name: data_reference
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      from gfdm.pygfdm import mapping
      from gfdm.pygfdm import utils
      from gfdm.pygfdm import preamble as pre_module
      from gfdm.pygfdm.gfdm_modulation import modulate_mapped_gfdm_block
      from gfdm.pygfdm.cyclic_prefix import add_cyclic_starfix, get_raised_cosine_ramp, pinch_block, get_window_len


      def generate_payload(timeslots=9, subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          cs_len = ramp_len
          seed = utils.generate_seed('awesome frame')
          d = utils.get_random_qpsk(timeslots * active_subcarriers, seed)
          frame = modulate_mapped_gfdm_block(d, timeslots, subcarriers, active_subcarriers, overlap, .2, dc_free=True)
          symbol = add_cyclic_starfix(frame, cp_len, cs_len)
          window_ramp = get_raised_cosine_ramp(cs_len, get_window_len(cp_len, timeslots, subcarriers, cs_len))
          return pinch_block(symbol, window_ramp)


      def generate_preambles(subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          subcarrier_map = mapping.get_subcarrier_map(subcarriers, active_subcarriers, dc_free=True)
          seed = utils.generate_seed('awesome preamble')
          print('Fancy preamble seed: ', utils.generate_seed('awesome preamble'))
          seed = int(3660365253)
          print('static preamble seed: ', seed)
          preambles = pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
          return preambles

      preambles = generate_preambles()
      full_preamble = preambles[0]
      core_preamble = preambles[1]

      print(full_preamble.size)
      print(core_preamble.size)


      payload = generate_payload()

      #reference_frame = np.concatenate((full_preamble, payload))
  states: {}
- name: delay_auto_correlator
  id: xfdm_sync_sc_delay_corr
  parameters:
    normalize: 'False'
    seq_len: len(data_reference.core_preamble) // 2
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: polarwrap_tag_to_stream_value_0
  id: polarwrap_tag_to_stream_value
  parameters:
    dict_key: '"sc_idx"'
    type: int
  states: {state: disabled}
- name: polarwrap_tag_to_stream_value_0_0
  id: polarwrap_tag_to_stream_value
  parameters:
    dict_key: '"xcorr_idx"'
    type: int
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: int
  states: {state: disabled}
- name: qtgui_time_sink_auto_corr_tagged
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:1,0,1,1
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: '"SC vs Source"'
    nconnections: '2'
    size: 1024*16 * 4
    srate: samp_rate
    tr_chan: '2'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"preamble_start"'
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_receive_stream
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:0,0,1,1
    label1: ''
    label2: ''
    name: '"RX samples"'
    size: 1024*32
    srate: samp_rate
    tr_delay: '200e-6'
    tr_level: '0.02'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"preamble_start"'
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_synchronized_stream
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:2,0,1,1
    label1: ''
    label2: ''
    name: '"Synchronized stream"'
    size: int(2 ** 16)
    srate: samp_rate
    tr_chan: '1'
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: sync_key
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_synchronized_stream_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: sync_tab@0:3,0,1,1
    label1: ''
    label2: ''
    name: '"auto corr rotation"'
    nconnections: '2'
    size: int(2 ** 10)
    srate: samp_rate
    tr_delay: '200e-6'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: sync_key
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,4,3
    label0: Synchronization
    num_tabs: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: tfreq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"name=misspiggy"'
    dev_args: '""'
    gain0: rgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [auto_corr_tagger, '0', cross_corr_tagger, '0']
- [auto_corr_tagger, '0', qtgui_time_sink_auto_corr_tagged, '0']
- [auto_corr_tagger, '1', corr_mag_squared, '0']
- [auto_corr_tagger, '1', cross_corr_tagger, '1']
- [blocks_int_to_float_0, '0', qtgui_time_sink_synchronized_stream_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_synchronized_stream_0, '1']
- [corr_mag_sq_complex, '0', qtgui_time_sink_auto_corr_tagged, '1']
- [corr_mag_squared, '0', corr_mag_sq_complex, '0']
- [cross_corr_tagger, '0', blocks_null_sink_0, '0']
- [cross_corr_tagger, '0', blocks_tag_debug_0, '0']
- [cross_corr_tagger, '0', polarwrap_tag_to_stream_value_0, '0']
- [cross_corr_tagger, '0', polarwrap_tag_to_stream_value_0_0, '0']
- [cross_corr_tagger, '0', qtgui_time_sink_synchronized_stream, '0']
- [delay_auto_correlator, '0', auto_corr_tagger, '0']
- [delay_auto_correlator, '1', auto_corr_tagger, '1']
- [polarwrap_tag_to_stream_value_0, '0', blocks_int_to_float_0_0, '0']
- [polarwrap_tag_to_stream_value_0, '0', qtgui_number_sink_0, '0']
- [polarwrap_tag_to_stream_value_0_0, '0', blocks_int_to_float_0, '0']
- [uhd_usrp_source_0, '0', delay_auto_correlator, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_receive_stream, '0']

metadata:
  file_format: 1
