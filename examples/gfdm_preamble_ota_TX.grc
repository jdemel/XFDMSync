options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_preamble_ota_TX
    output_language: python
    title: Zadoff Chu OTA Demo
  states: {}

blocks:
- name: full_preamble
  id: variable
  parameters:
    value: data_reference.full_preamble
  states: {}
- name: reference_data
  id: variable
  parameters:
    value: data_reference.reference
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6 / 64 * 2
  states: {}
- name: tfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:0,0,1,1
    label: Carrier Frequency
    orient: Qt.Horizontal
    start: 2.4e9
    step: '1'
    stop: 3.8e9
    value: 2.484e9
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:1,0,1,1
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '20.'
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: '4096'
    type: complex
    vector: '[0, ] * (4096 - len(reference_data))'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: reference_data
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,4,1,1
    label0: Control
    num_tabs: '1'
  states: {}
- name: data_reference
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      from gfdm.pygfdm import mapping
      from gfdm.pygfdm import utils
      from gfdm.pygfdm import preamble as pre_module
      from gfdm.pygfdm.gfdm_modulation import modulate_mapped_gfdm_block
      from gfdm.pygfdm.cyclic_prefix import add_cyclic_starfix, get_raised_cosine_ramp, pinch_block, get_window_len


      def generate_payload(timeslots=9, subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          cs_len = ramp_len
          seed = utils.generate_seed('awesome frame')
          d = utils.get_random_qpsk(timeslots * active_subcarriers, seed)
          frame = modulate_mapped_gfdm_block(d, timeslots, subcarriers, active_subcarriers, overlap, .2, dc_free=True)
          symbol = add_cyclic_starfix(frame, cp_len, cs_len)
          window_ramp = get_raised_cosine_ramp(cs_len, get_window_len(cp_len, timeslots, subcarriers, cs_len))
          return pinch_block(symbol, window_ramp)


      def generate_preambles(subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          subcarrier_map = mapping.get_subcarrier_map(subcarriers, active_subcarriers, dc_free=True)
          print('Fancy preamble seed: ', utils.generate_seed('awesome preamble'))
          seed = int(3660365253)
          print('static preamble seed: ', seed)
          preambles = pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
          return preambles

      preambles = generate_preambles()
      full_preamble = preambles[0]
      core_preamble = preambles[1]

      print(full_preamble.size)
      print(core_preamble.size)

      payload = generate_payload()

      reference = np.concatenate((full_preamble, payload))
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tfreq
    clock_rate: '0.0'
    dev_addr: '"name=kermit"'
    dev_args: '""'
    gain0: tgain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_vector_insert_x_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_insert_x_0, '0']

metadata:
  file_format: 1
