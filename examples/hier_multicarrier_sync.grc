options:
  parameters:
    author: Johannes Demel
    category: '[xfdm_sync]'
    generate_options: hb
    id: hier_multicarrier_sync
    output_language: python
    title: Multicarrier Sync
  states: {}

blocks:
- name: preamble_len
  id: variable
  parameters:
    value: len(ref_preamble)
  states: {}
- name: frames_0
  id: pad_sink
  parameters:
    label: stream
    type: complex
  states: {}
- name: frames_0_0
  id: pad_sink
  parameters:
    label: xcorr
    optional: 'True'
    type: complex
  states: {}
- name: frames_0_0_0
  id: pad_sink
  parameters:
    label: acorr
    optional: 'True'
    type: complex
  states: {}
- name: frames_0_0_0_0
  id: pad_sink
  parameters:
    label: astream
    optional: 'True'
    type: complex
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: output_tag_key
  id: parameter
  parameters:
    label: Frame Tag Key
    type: str
    value: '"frame_start"'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: ref_preamble
  id: parameter
  parameters:
    label: Preamble
    value: np.ones(128)
  states: {}
- name: sc_high_thr
  id: parameter
  parameters:
    label: SC Higher Threshold
    type: eng_float
    value: '.7'
  states: {}
- name: sc_low_thr
  id: parameter
  parameters:
    label: SC Lower Threshold
    type: eng_float
    value: '.6'
  states: {}
- name: xcorr_comp_freq
  id: parameter
  parameters:
    label: Xcorr compensate freq.
    value: 'False'
  states: {}
- name: xcorr_det_thr
  id: parameter
  parameters:
    label: XCorr Detection Threshold
    type: eng_float
    value: '100.'
  states: {}
- name: xfdm_sync_sc_delay_corr_0_0
  id: xfdm_sync_sc_delay_corr
  parameters:
    normalize: 'True'
    seq_len: preamble_len // 2
  states: {}
- name: xfdm_sync_sc_tagger_0_0
  id: xfdm_sync_sc_tagger
  parameters:
    seq_len: preamble_len // 2
    tag_key: output_tag_key
    thres_high: sc_high_thr
    thres_low: sc_low_thr
  states: {}
- name: xfdm_sync_xcorr_tagger_0_0
  id: xfdm_sync_xcorr_tagger
  parameters:
    sync_sequence: ref_preamble
    tag_key: output_tag_key
    threshold: xcorr_det_thr
    use_sc_rot: xcorr_comp_freq
  states: {}

connections:
- [pad_source_0, '0', xfdm_sync_sc_delay_corr_0_0, '0']
- [xfdm_sync_sc_delay_corr_0_0, '0', xfdm_sync_sc_tagger_0_0, '0']
- [xfdm_sync_sc_delay_corr_0_0, '1', xfdm_sync_sc_tagger_0_0, '1']
- [xfdm_sync_sc_tagger_0_0, '0', frames_0_0_0_0, '0']
- [xfdm_sync_sc_tagger_0_0, '0', xfdm_sync_xcorr_tagger_0_0, '0']
- [xfdm_sync_sc_tagger_0_0, '1', frames_0_0_0, '0']
- [xfdm_sync_sc_tagger_0_0, '1', xfdm_sync_xcorr_tagger_0_0, '1']
- [xfdm_sync_xcorr_tagger_0_0, '0', frames_0, '0']
- [xfdm_sync_xcorr_tagger_0_0, '1', frames_0_0, '0']

metadata:
  file_format: 1
